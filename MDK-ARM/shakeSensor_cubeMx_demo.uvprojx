# Keil uVision project shakeSensor_cubeMx_demo.uvprojx, settings and files
target shakeSensor_cubeMx_demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L051R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: shakeSensor_cubeMx_demo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;..\Inc_App;..\Src_App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Application/User
    ../Src/: stm32l0xx_it.c stm32l0xx_hal_msp.c main.c
    ../Src_App/: ShakeSensor_app.c
    ../Inc_App/: ShakeSensor_app.h L3GD20H.h adxl375.h
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_spi.c stm32l0xx_hal_adc.c stm32l0xx_hal.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_wwdg.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_flash.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_tim.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_rtc.c
software components: CMSIS:CORE 4.1.0
